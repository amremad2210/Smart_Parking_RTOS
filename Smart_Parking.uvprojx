# Keil uVision project Smart_Parking.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Smart_Parking
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=1
  c include: .\Required_Files;C:\ti\TivaWare_C_Series-2.2.0.295;C:\ti\TivaWare_C_Series-2.2.0.295\inc;C:\ti\TivaWare_C_Series-2.2.0.295\driverlib;.\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: C:\ti\TivaWare_C_Series-2.2.0.295\driverlib\rvmdk\driverlib.lib
  group Source Group 1
    ./: main.c
    ./Required_Files/: basic_io.c consoleprint.c retarget.c
    ./src/: board_io.c gate_control_task.c gate_fsm.c input_task.c led_task.c safety_task.c status_task.c
    ./inc/: app_config.h board_io.h gate_control_task.h gate_fsm.h gate_shared.h gate_types.h input_task.h led_task.h safety_task.h status_task.h
software components: RTOS:Config 11.2.0, RTOS:Core 11.2.0, RTOS:Event Groups 11.2.0, RTOS:Heap 11.2.0, RTOS:Timers 11.2.0, CMSIS:CORE 6.2.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:FreeRTOS 11.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.1
